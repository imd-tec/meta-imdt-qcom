PACKAGE_INSTALL:remove = "first-stage-scripts-init"
