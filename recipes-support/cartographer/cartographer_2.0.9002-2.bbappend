#
# Copyright (c) 2024 IMD Technologies
#

FILESEXTRAPATHS:prepend := "${THISDIR}/${BPN}:"

SRC_URI += "file://0001-Remove-include-in-functions_cmake_module.patch"
