#
# Copyright (c) 2026 IMD Technologies
#

FILESEXTRAPATHS:prepend := "${THISDIR}/files:"
